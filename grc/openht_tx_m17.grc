options:
  parameters:
    author: Wojciech Kaczmarski SP5WWP
    copyright: M17 Project
    generate_options: qt_gui
    id: options_0
    output_language: python
    title: OpenHT M17 TX path sim
  states: {}

blocks:
- name: N1
  id: variable
  parameters:
    value: '405'
  states: {}
- name: N2
  id: variable
  parameters:
    value: '205'
  states: {}
- name: N3
  id: variable
  parameters:
    value: '100'
  states: {}
- name: decim_1
  id: variable
  parameters:
    value: '3'
  states: {}
- name: fm_dev
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: gain_1
  id: variable
  parameters:
    value: '5'
  states: {}
- name: gain_2
  id: variable
  parameters:
    value: '5'
  states: {}
- name: gain_3
  id: variable
  parameters:
    value: '2'
  states: {}
- name: interp_1
  id: variable
  parameters:
    value: '25'
  states: {}
- name: interp_2
  id: variable
  parameters:
    value: '5'
  states: {}
- name: interp_3
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*math.pi*fm_dev)/(samp_rate*interp_1*interp_2*interp_3)
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: 1.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: decim_1
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: interp_1
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: interp_2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: interp_3
    type: float
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*interp_1*interp_2*interp_3/decim_1
    type: complex
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: (1.0, 3.0, -1.0, -3.0)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from scipy import signal as scisig
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import commpy
  states: {state: disabled}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: interp_1
    taps: scisig.remez(N1, [0, 3800, 4200, samp_rate*interp_1/2], [1.0, 0], fs=samp_rate*interp_1)
    type: fff
  states: {state: disabled}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: interp_2
    taps: scisig.remez(N2, [0, 4400, 10000, samp_rate*interp_1*interp_2/2], [1.0, 0], fs=samp_rate*interp_1*interp_2)
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_1
  id: interp_fir_filter_xxx
  parameters:
    interp: interp_3
    taps: scisig.remez(N3, [0, 4400, 30000, samp_rate*interp_1*interp_2*interp_3/2], [1.0, 0], fs=samp_rate*interp_1*interp_2*interp_3)
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_2
  id: interp_fir_filter_xxx
  parameters:
    interp: interp_1
    taps: rrcosfilter(N1, 0.5, 1.0/(samp_rate), samp_rate*interp_1)
    type: fff
  states: {state: disabled}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '17005'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: '10'
    size: '4800'
    srate: 48e3
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*interp_1*interp_2*interp_3/decim_1
    fc: '0'
    fftsize: '1024'
    legend: 'False'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*interp_1*interp_2*interp_3/decim_1
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    legend: 'False'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    legend: 'False'
    size: 4800*4
    srate: samp_rate*interp_1*interp_2*interp_3/decim_1
    type: float
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*interp_1*interp_2*interp_3/decim_1
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    legend: 'False'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '3'
    taps: ''
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '1.0'
    interp: interp_1
    ntaps: N1
    samp_rate: interp_1
    sym_rate: '1.0'
    type: interp_fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1.0'
    ntaps: '81'
    samp_rate: '10'
    sym_rate: '1.0'
    type: fir_filter_fff
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_keep_one_in_n_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', interp_fir_filter_xxx_0_1, '0']
- [blocks_multiply_const_vxx_0_1, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', rational_resampler_xxx_0, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_throttle2_0, '0', network_udp_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0_2, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [interp_fir_filter_xxx_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [interp_fir_filter_xxx_0_2, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [root_raised_cosine_filter_0_0, '0', qtgui_eye_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
